## tests/unit/testcase.yaml
```yaml
tests:
  unit_tests.mytest:
    tags: okay
    type: unit
    # platform_allow: native_posix
```
